# Keil uVision project Stm32Adc.uvproj, settings and files
target AllStm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Stm32Adc
  c flags: Optim=1
  c include: .\boot;.\interrupt;.\library\inc;.\library\src;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group boot
    ./boot/: cortexm3_macro.s stm32f10x_vector.s
  group library
    ./library/src/: stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group src
    ./src/: main.c adc.c data.h pid.c pwm.c
  group interrupt
    ./interrupt/: stm32f10x_it.c
